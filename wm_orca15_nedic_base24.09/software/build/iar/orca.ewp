# IAR project orca.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM370FYFG Toshiba TMPM370FYFG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: WM_MODEL_11KG; ZCD_SYNC_ENABLE; LID_CLOSE_PERMENENT; ERROR_DISABLE; STANDBY_TIMEOUT_DISABLE; PAUSE_TIMEOUT_DISABLE; AUTO_DETERGENT_HEATER_MODEL; LOG_ENABLE
  ICCARM.CCIncludePath2: ..\..\source\app\config; ..\..\source\app\entry\inc; ..\..\source\app\exit\inc; ..\..\source\app\interrupt\inc; ..\..\source\app\pm\0_startup_mode\inc; ..\..\source\app\pm\1_setup_mode\inc; ..\..\source\app\pm\2_standby_mode\inc; ..\..\source\app\pm\3_normal_mode\0_nm_init\inc; ..\..\source\app\pm\3_normal_mode\1_nm_wash\inc; ..\..\source\app\pm\3_normal_mode\3_nm_tubclean\inc; ..\..\source\app\pm\3_normal_mode\4_nm_pause\inc; ..\..\source\app\pm\3_normal_mode\5_nm_finish\inc; ..\..\source\app\pm\3_normal_mode\nm\inc; ..\..\source\app\pm\4_test_mode\inc; ..\..\source\app\pm\5_fault_mode\inc; ..\..\source\app\pm\6_finish_mode\inc; ..\..\source\app\pm\processor\inc; ..\..\source\core\tmpm370\inc; ..\..\source\handlers\input\inc; ..\..\source\handlers\output\inc; ..\..\source\mcal; ..\..\source\mcal\tmpm370\inc; ..\..\source\os\inc; ..\..\source\os\utils\inc; ..\..\source\os\port\inc; ..\..\source\os\port\tmpm370\inc; ..\..\source\components\acin; ..\..\source\components\ainput_module; ..\..\source\components\buzzer; ..\..\source\components\com_display; ..\..\source\components\crc16; ..\..\source\components\dinput_module; ..\..\source\components\doutput_module; ..\..\source\components\finput_module; ..\..\source\components\gpio; ..\..\source\components\heartbeat; ..\..\source\components\hm15n; ..\..\source\components\hw_timer; ..\..\source\components\itw_lock; ..\..\source\components\keypad; ..\..\source\components\kx022; ..\..\source\components\ddm_motor; ..\..\source\components\ntc_temp_sensor; ..\..\source\components\ptc_heater; ..\..\source\components\s15d; ..\..\source\components\sspi; ..\..\source\components\stwi; ..\..\source\components\timer_sandwich; ..\..\source\components\twi_eeprom; ..\..\source\components\uart; ..\..\source\components\wdt; ..\..\source\components\wl90at; ..\..\source\components\zcd; ..\..\source; ..\..\source\components; ..\..\source\app\pm\3_normal_mode\2_nm_dry\inc; ..\..\source\components\ela_inverter\McApp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: orca.srec
  ILINK.IlinkOutputFile: orca.out
  ILINK.IlinkIcfFile: TMPM370FYFG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app/config
    ../../source/app/config/: board.h board_tmpm370.h component_config.h config.h def.h MC_config.h os_config.h version.h
  group app/entry/inc
    ../../source/app/entry/inc/: app_entry.h app_entry_startup.h
  group app/entry/src
    ../../source/app/entry/src/: app_entry.c app_entry_startup.c
  group app/exit/inc
    ../../source/app/exit/inc/: app_exit_shutdown.h
  group app/exit/src
    ../../source/app/exit/src/: app_exit_shutdown.c
  group app/interrupt/inc
    ../../source/app/interrupt/inc/: app_interrupt.h
  group app/interrupt/src
    ../../source/app/interrupt/src/: app_interrupt.c
  group app/pm/0_startup_mode/inc
    ../../source/app/pm/0_startup_mode/inc/: app_startup.h app_startup_display.h app_startup_drain.h app_startup_fill.h app_startup_heater.h app_startup_lid.h app_startup_memory.h app_startup_motor.h app_startup_user_interface.h
  group app/pm/0_startup_mode/src
    ../../source/app/pm/0_startup_mode/src/: app_startup.c app_startup_display.c app_startup_drain.c app_startup_fill.c app_startup_heater.c app_startup_lid.c app_startup_memory.c app_startup_motor.c app_startup_user_interface.c
  group app/pm/1_setup_mode/inc
    ../../source/app/pm/1_setup_mode/inc/: app_setup.h app_setup_display.h app_setup_drain.h app_setup_fill.h app_setup_heater.h app_setup_lid.h app_setup_memory.h app_setup_motor.h app_setup_user_interface.h
  group app/pm/1_setup_mode/src
    ../../source/app/pm/1_setup_mode/src/: app_setup.c app_setup_display.c app_setup_drain.c app_setup_fill.c app_setup_heater.c app_setup_lid.c app_setup_memory.c app_setup_motor.c app_setup_user_interface.c
  group app/pm/2_standby_mode/inc
    ../../source/app/pm/2_standby_mode/inc/: app_standby.h app_standby_display.h app_standby_drain.h app_standby_fill.h app_standby_heater.h app_standby_lid.h app_standby_memory.h app_standby_motor.h app_standby_user_interface.h
  group app/pm/2_standby_mode/src
    ../../source/app/pm/2_standby_mode/src/: app_standby.c app_standby_display.c app_standby_drain.c app_standby_fill.c app_standby_heater.c app_standby_lid.c app_standby_memory.c app_standby_motor.c app_standby_user_interface.c
  group app/pm/3_normal_mode/0_nm_init/inc
    ../../source/app/pm/3_normal_mode/0_nm_init/inc/: app_nm_init.h app_nm_init_display.h app_nm_init_drain.h app_nm_init_fill.h app_nm_init_heater.h app_nm_init_lid.h app_nm_init_motor.h app_nm_init_user_interface.h
  group app/pm/3_normal_mode/0_nm_init/src
    ../../source/app/pm/3_normal_mode/0_nm_init/src/: app_nm_init.c app_nm_init_display.c app_nm_init_drain.c app_nm_init_fill.c app_nm_init_heater.c app_nm_init_lid.c app_nm_init_motor.c app_nm_init_user_interface.c
  group app/pm/3_normal_mode/1_nm_wash/inc
    ../../source/app/pm/3_normal_mode/1_nm_wash/inc/: app_nm_wash.h app_nm_wash_data.h app_nm_wash_defaults.h app_nm_wash_display.h app_nm_wash_drain.h app_nm_wash_fill.h app_nm_wash_heater.h app_nm_wash_heater_table.h app_nm_wash_lid.h app_nm_wash_motor.h app_nm_wash_motor_table.h app_nm_wash_rinse.h app_nm_wash_rinse_fill_table.h app_nm_wash_rinse_motor_table.h app_nm_wash_rinse_table.h app_nm_wash_soak_motor_table.h app_nm_wash_soak_table.h app_nm_wash_spin.h app_nm_wash_spin_motor_table.h app_nm_wash_steam_motor_table.h app_nm_wash_steam_table.h app_nm_wash_user_interface.h app_nm_wash_wash_detergent_table.h app_nm_wash_wash_motor_table.h app_nm_wash_wash_table.h
  group app/pm/3_normal_mode/1_nm_wash/src
    ../../source/app/pm/3_normal_mode/1_nm_wash/src/: app_nm_wash.c app_nm_wash_display.c app_nm_wash_drain.c app_nm_wash_fill.c app_nm_wash_heater.c app_nm_wash_heater_table.c app_nm_wash_lid.c app_nm_wash_motor.c app_nm_wash_motor_table.c app_nm_wash_rinse.c app_nm_wash_rinse_fill_table.c app_nm_wash_rinse_table.c app_nm_wash_setup.c app_nm_wash_soak.c app_nm_wash_spin.c app_nm_wash_spin_table.c app_nm_wash_steam.c app_nm_wash_steam_table.c app_nm_wash_user_interface.c app_nm_wash_wash.c app_nm_wash_wash_table.c
  group app/pm/3_normal_mode/3_nm_tubclean/inc
    ../../source/app/pm/3_normal_mode/3_nm_tubclean/inc/: app_nm_tubclean.h app_nm_tubclean_defaults.h app_nm_tubclean_display.h app_nm_tubclean_drain.h app_nm_tubclean_fill.h app_nm_tubclean_heater.h app_nm_tubclean_heater_table.h app_nm_tubclean_lid.h app_nm_tubclean_motor.h app_nm_tubclean_motor_table.h app_nm_tubclean_table.h app_nm_tubclean_user_interface.h
  group app/pm/3_normal_mode/3_nm_tubclean/src
    ../../source/app/pm/3_normal_mode/3_nm_tubclean/src/: app_nm_tubclean.c app_nm_tubclean_display.c app_nm_tubclean_drain.c app_nm_tubclean_fill.c app_nm_tubclean_heater.c app_nm_tubclean_heater_table.c app_nm_tubclean_lid.c app_nm_tubclean_motor.c app_nm_tubclean_motor_table.c app_nm_tubclean_table.c app_nm_tubclean_user_interface.c
  group app/pm/3_normal_mode/4_nm_pause/inc
    ../../source/app/pm/3_normal_mode/4_nm_pause/inc/: app_nm_pause.h app_nm_pause_display.h app_nm_pause_drain.h app_nm_pause_fill.h app_nm_pause_heater.h app_nm_pause_lid.h app_nm_pause_motor.h app_nm_pause_user_interface.h
  group app/pm/3_normal_mode/4_nm_pause/src
    ../../source/app/pm/3_normal_mode/4_nm_pause/src/: app_nm_pause.c app_nm_pause_display.c app_nm_pause_drain.c app_nm_pause_fill.c app_nm_pause_heater.c app_nm_pause_lid.c app_nm_pause_motor.c app_nm_pause_user_interface.c
  group app/pm/3_normal_mode/5_nm_finish/inc
    ../../source/app/pm/3_normal_mode/5_nm_finish/inc/: app_nm_finish.h app_nm_finish_display.h app_nm_finish_drain.h app_nm_finish_fill.h app_nm_finish_heater.h app_nm_finish_lid.h app_nm_finish_motor.h app_nm_finish_user_interface.h
  group app/pm/3_normal_mode/5_nm_finish/src
    ../../source/app/pm/3_normal_mode/5_nm_finish/src/: app_nm_finish.c app_nm_finish_display.c app_nm_finish_drain.c app_nm_finish_fill.c app_nm_finish_heater.c app_nm_finish_lid.c app_nm_finish_motor.c app_nm_finish_user_interface.c
  group app/pm/3_normal_mode/nm/inc
    ../../source/app/pm/3_normal_mode/nm/inc/: app_nm.h app_nm_data_display.h app_nm_display.h app_nm_drain.h app_nm_endurance.h app_nm_fill.h app_nm_heater.h app_nm_lid.h app_nm_log.h app_nm_memory.h app_nm_motor.h app_nm_user_interface.h
  group app/pm/3_normal_mode/nm/src
    ../../source/app/pm/3_normal_mode/nm/src/: app_nm.c app_nm_data_display.c app_nm_display.c app_nm_drain.c app_nm_endurance.c app_nm_fill.c app_nm_heater.c app_nm_lid.c app_nm_log.c app_nm_memory.c app_nm_motor.c app_nm_user_interface.c
  group app/pm/4_test_mode/inc
    ../../source/app/pm/4_test_mode/inc/: app_test_mode.h app_tm_display.h app_tm_drain.h app_tm_fill.h app_tm_heater.h app_tm_lid.h app_tm_memory.h app_tm_motor.h app_tm_user_interface.h
  group app/pm/4_test_mode/src
    ../../source/app/pm/4_test_mode/src/: app_test_mode.c app_tm_cycle_count_display.c app_tm_display.c app_tm_drain.c app_tm_electrical_parts.c app_tm_error_count_display.c app_tm_fill.c app_tm_final_inspection.c app_tm_heater.c app_tm_lid.c app_tm_lv_calibration.c app_tm_memory.c app_tm_middle_inspection.c app_tm_motor.c app_tm_pcb.c app_tm_unbalance_spin.c app_tm_user_interface.c app_tm_water_level_calibration.c app_tm_water_level_freq.c app_tm_weight_calibration.c
  group app/pm/5_fault_mode/inc
    ../../source/app/pm/5_fault_mode/inc/: app_fault.h app_fault_display.h app_fault_drain.h app_fault_fill.h app_fault_heater.h app_fault_lid.h app_fault_memory.h app_fault_motor.h app_fault_user_interface.h
  group app/pm/5_fault_mode/src
    ../../source/app/pm/5_fault_mode/src/: app_fault.c app_fault_display.c app_fault_drain.c app_fault_fill.c app_fault_heater.c app_fault_lid.c app_fault_memory.c app_fault_motor.c app_fault_user_interface.c
  group app/pm/6_finish_mode/inc
    ../../source/app/pm/6_finish_mode/inc/: app_finish.h app_finish_display.h app_finish_drain.h app_finish_fill.h app_finish_heater.h app_finish_lid.h app_finish_memory.h app_finish_motor.h app_finish_user_interface.h
  group app/pm/6_finish_mode/src
    ../../source/app/pm/6_finish_mode/src/: app_finish.c app_finish_display.c app_finish_drain.c app_finish_fill.c app_finish_heater.c app_finish_lid.c app_finish_memory.c app_finish_motor.c app_finish_user_interface.c
  group app/pm/processor/inc
    ../../source/app/pm/processor/inc/: app_buzzer.h app_component_mocker.h app_controller.h app_display.h app_drain.h app_fill.h app_heater.h app_lid.h app_load.h app_memory.h app_motor.h app_processor.h app_unbalance.h app_user_interface.h
  group app/pm/processor/src
    ../../source/app/pm/processor/src/: app_buzzer.c app_component_mocker.c app_controller.c app_display.c app_drain.c app_fill.c app_heater.c app_lid.c app_load.c app_memory.c app_motor.c app_processor.c app_unbalance.c app_user_interface.c
  group components/acin
    ../../source/components/acin/: acin.c acin.h
  group components/ainput_module
    ../../source/components/ainput_module/: ainput_module.c ainput_module.h
  group components/buzzer
    ../../source/components/buzzer/: buzzer.c buzzer.h
  group components/com_display
    ../../source/components/com_display/: com_display.c com_display.h
  group components/crc16
    ../../source/components/crc16/: crc16.c crc16.h
  group components/ddm_motor
    ../../source/components/ddm_motor/: ddm_motor.c ddm_motor.h
  group components/dinput_module
    ../../source/components/dinput_module/: dinput_module.c dinput_module.h
  group components/dls35s
    ../../source/components/dls35s/: dls35s.c dls35s.h
  group components/doutput_module
    ../../source/components/doutput_module/: doutput_module.c doutput_module.h
  group components/ela_inverter/McApp
    ../../source/components/ela_inverter/McApp/: APP_measurement.c APP_measurement.h AppWashingMachine.h communication.c communication.h HEART_BEAT.c HEART_BEAT.h inverter.c inverter.h MC_interface.c MC_interface.h McBoard.h McMain.c McMain.h McProject.h power_relay.c power_relay.h
  group components/ela_inverter/McDev
    ../../source/components/ela_inverter/McDev/: DevMotor.c DevMotor.h McMotor.h
  group components/ela_inverter/McUtil
    ../../source/components/ela_inverter/McUtil/: cpu.h DevPeripheral.c DevPeripheral.h McTarget.c McTarget.h McUtil.c McUtil.h
  group components/finput_module
    ../../source/components/finput_module/: finput_module.c finput_module.h
  group components/gpio
    ../../source/components/gpio/: gpio.c gpio.h
  group components/hm15n
    ../../source/components/hm15n/: hm15n.c hm15n.h
  group components/hw_timer
    ../../source/components/hw_timer/: hw_timer.c hw_timer.h
  group components/keypad
    ../../source/components/keypad/: keypad.c keypad.h keypad_def.h
  group components/kx022
    ../../source/components/kx022/: kx022.c kx022.h
  group components/ntc_temp_sensor
    ../../source/components/ntc_temp_sensor/: ntc_temp_sensor.c ntc_temp_sensor.h
  group components/ptc_heater
    ../../source/components/ptc_heater/: ptc_heater.c ptc_heater.h
  group components/sspi
    ../../source/components/sspi/: sspi.c sspi.h
  group components/stwi
    ../../source/components/stwi/: stwi.c stwi.h
  group components/timer_sandwich
    ../../source/components/timer_sandwich/: timer_sandwich.c timer_sandwich.h
  group components/twi_eeprom
    ../../source/components/twi_eeprom/: twi_eeprom.c twi_eeprom.h
  group components/uart
    ../../source/components/uart/: uart.c uart.h
  group components/wdt
    ../../source/components/wdt/: wdt.c wdt.h
  group components/wl90at
    ../../source/components/wl90at/: wl90at.c wl90at.h
  group components/zcd
    ../../source/components/zcd/: zcd.c zcd.h
  group core
    ../../source/core/: cpu_tmpm370f.asm
  group core/tmpm370/inc
    ../../source/core/tmpm370/inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h system_TMPM370.h TMPM370.h tmpm370_adc.h tmpm370_cg.h tmpm370_enc.h tmpm370_fc.h tmpm370_gpio.h tmpm370_ofd.h tmpm370_pmd.h tmpm370_tmrb.h tmpm370_uart.h tmpm370_vltd.h tmpm370_wdt.h tx03_common.h
  group core/tmpm370/src
    ../../source/core/tmpm370/src/: tmpm370_adc.c tmpm370_cg.c tmpm370_enc.c tmpm370_fc.c tmpm370_gpio.c tmpm370_ofd.c tmpm370_pmd.c tmpm370_tmrb.c tmpm370_uart.c tmpm370_vltd.c tmpm370_wdt.c
  group handlers/input/inc
    ../../source/handlers/input/inc/: handler_acin.h handler_crc.h handler_detergent_sensor.h handler_keypad.h handler_lid_sensor.h handler_load_sense.h handler_memory.h handler_mems.h handler_off_sw.h handler_power_detection.h handler_softener_sensor.h handler_temp_sensor.h handler_water_level.h
  group handlers/input/src
    ../../source/handlers/input/src/: handler_acin.c handler_crc.c handler_detergent_sensor.c handler_keypad.c handler_lid_sensor.c handler_load_sense.c handler_memory.c handler_mems.c handler_off_sw.c handler_power_detection.c handler_softener_sensor.c handler_temp_sensor.c handler_water_level.c
  group handlers/output/inc
    ../../source/handlers/output/inc/: handler_buzzer.h handler_clutch.h handler_clutch_hm15n.h handler_com.h handler_detergent_pump.h handler_display.h handler_drain_pump.h handler_drain_valve.h handler_drain_valve_hm15n.h handler_heater.h handler_lock_motor.h handler_motor.h handler_relay.h handler_softener_pump.h handler_water_valve.h
  group handlers/output/src
    ../../source/handlers/output/src/: handler_buzzer.c handler_clutch_hm15n.c handler_com.c handler_detergent_pump.c handler_display.c handler_drain_pump.c handler_drain_valve_hm15n.c handler_heater.c handler_lock_motor.c handler_motor.c handler_relay.c handler_softener_pump.c handler_water_valve.c
  group mcal
    ../../source/mcal/: mcal.h
  group mcal/tmpm370/inc
    ../../source/mcal/tmpm370/inc/: mcal_tmpm370.h
  group mcal/tmpm370/src
    ../../source/mcal/tmpm370/src/: mcal_tmpm370_adc.c mcal_tmpm370_clock.c mcal_tmpm370_exti.c mcal_tmpm370_gpio.c mcal_tmpm370_pwm.c mcal_tmpm370_systick.c mcal_tmpm370_timer.c mcal_tmpm370_uart.c mcal_tmpm370_wdt.c
  group os/inc
    ../../source/os/inc/: os.h os_init.h os_int.h os_log.h os_runtime.h os_scheduler.h os_tick.h os_timeout.h os_timer.h
  group os/port/inc
    ../../source/os/port/inc/: os_device_internals.h os_init.h os_int_handlers.h os_stack_health.h os_systick_handler.h
  group os/port/tmpm370/inc
    ../../source/os/port/tmpm370/inc/: os_port_int_handlers.h
  group os/port/tmpm370/src
    ../../source/os/port/tmpm370/src/: os_port_assert_failed.c os_port_device_internals.c os_port_int_handlers.c os_port_tick_handler.c startup_iar.c system_TMPM370.c
  group os/src
    ../../source/os/src/: main.c os_init.c os_int.c os_log.c os_runtime.c os_scheduler.c os_stack_health.c os_tick.c os_timeout.c os_timer.c
  group os/utils/inc
    ../../source/os/utils/inc/: utils.h
  group os/utils/src
    ../../source/os/utils/src/: utils.c
